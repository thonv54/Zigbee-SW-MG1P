# IAR project ZigbeeSW.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P132F256GM48 SiliconLaboratories EFR32MG1P132F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG_OFF; APP_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; PHY_RAIL; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeSW/ZigbeeSW_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeSW/ZigbeeSW_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeSW/ZigbeeSW_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeSW/ZigbeeSW.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4300B; SWITCH_1_BUTTON_V2; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-mfg-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; ZigbeeUtility; AppEvent; HalDelay; Uart_V2; CommonLed; CommonButton; Com; SW1_config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_OFF; APP_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_RAIL; EFR32_SERIES1_CONFIG1_MICRO; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeSW/ZigbeeSW_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeSW/ZigbeeSW_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeSW/ZigbeeSW_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeSW/ZigbeeSW.h"; BOARD_BRD4300B; SWITCH_1_BUTTON_V2; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-mfg-token.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; ZigbeeUtility; AppEvent; HalDelay; Uart_V2; CommonLed; CommonButton; Com; SW1_config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  OBJCOPY.OOCOutputFile: ZigbeeSW.s37
  postbuild: ZigbeeSW.bat $TARGET_BPATH$ "$PROJ_DIR$"
  ILINK.IlinkOutputFile: ZigbeeSW.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=262144; RAM_SIZE=32768; APP_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
configuration SW1 (ARM, debug)
  as the first configuration, except:
configuration SW2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG_OFF; APP_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; PHY_RAIL; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeSW/SW2_config/ZigbeeSW_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeSW/ZigbeeSW_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeSW/ZigbeeSW_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeSW/SW2_config/ZigbeeSW.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4300B; SWITCH_2_BUTTON_V2; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-mfg-token.h"
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; ZigbeeUtility; AppEvent; HalDelay; Uart_V2; CommonLed; CommonButton; Com; SW2_config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  OBJCOPY.OOCOutputFile: SW2.s37
  ILINK.IlinkOutputFile: SW2.out
configuration SW3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG_OFF; APP_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; PHY_RAIL; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeSW/SW3_config/ZigbeeSW_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeSW/ZigbeeSW_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeSW/ZigbeeSW_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeSW/SW3_config/ZigbeeSW.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4300B; SWITCH_3_BUTTON_V2; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-mfg-token.h"
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; ZigbeeUtility; AppEvent; HalDelay; Uart_V2; CommonLed; CommonButton; Com; SW3_config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  OBJCOPY.OOCOutputFile: SW3.s37
  ILINK.IlinkOutputFile: SW3.out
configuration SW4 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG_OFF; APP_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG1_MICRO; PHY_RAIL; EFR32MG1P; EFR32MG1P132F256GM48; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeSW/SW4_config/ZigbeeSW_endpoint_config.h"; BOARD_HEADER="app/builder/ZigbeeSW/ZigbeeSW_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeSW/ZigbeeSW_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeSW/SW4_config/ZigbeeSW.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4300B; SWITCH_4_BUTTON_V2; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/ZigbeeSW/afv2-mfg-token.h"
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee_5.9\app\framework; ..\..\..\protocol\zigbee_5.9\app\framework\..\..; ..\..\..\protocol\zigbee_5.9\app\framework\..\..\stack; ..\..\..\protocol\zigbee_5.9\app\framework\..\util; ..\..\..\protocol\zigbee_5.9\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ecode; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\hardware\kit\common\bsp; ..\..\..\hardware\kit\EFR32MG1_BRD4300B\config; ..\..\..\platform\bootloader; ZigbeeUtility; AppEvent; HalDelay; Uart_V2; CommonLed; CommonButton; Com; SW4_config; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\radio\rail_lib\chip\efr32
  OBJCOPY.OOCOutputFile: SW4.s37
  ILINK.IlinkOutputFile: SW4.out
configuration DZ1 (ARM, debug)
  as the first configuration, except:
configuration DZ2 (ARM, debug)
  as the first configuration, except:
configuration FZ1 (ARM, debug)
  as the first configuration, except:
configuration BZ1 (ARM, debug)
  as the first configuration, except:
configuration BZ2 (ARM, debug)
  as the first configuration, except:
  group (top)
    ../../../platform/base/hal/plugin/adc/: adc-efr32.c
    ../../../protocol/zigbee_5.9/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c util.c
    ../../../protocol/zigbee_5.9/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c cli.c stack-handler-stub.c ZigbeeSW_callbacks.c
    ../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    AppEvent/: AppEvent.c
    ../../../platform/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c bootloader-interface-app.c bootloader-interface.c button.c cstartup-common.c diagnostic.c ext-device.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c
    ../../../platform/bootloader/api/: btl_interface.c btl_interface_storage.c
    ../../../platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ../../../platform/base/hal/plugin/coexistence/: coexistence-efr32.c
    ../../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../protocol/zigbee_5.9/app/util/serial/: command-interpreter2.c
    CommonButton/: CommonButton.c
    CommonLed/: CommonLed.c
    ../../../protocol/zigbee_5.9/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/eeprom/: eeprom-cli.c eeprom.c
    ../../../platform/base/hal/: ember-base-configuration.c
    ../../../protocol/zigbee_5.9/stack/config/: ember-configuration.c
    ../../../platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ezmode-commissioning/: ez-mode-cli.c ez-mode.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../protocol/zigbee_5.9/app/util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/groups-server/: groups-server-cli.c groups-server.c
    HalDelay/: halDelay.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/identify/: identify-cli.c identify.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/identify-feedback/: identify-feedback.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/network-find/: network-find.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/on-off/: on-off.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-bootload/: ota-bootload-cli.c ota-bootload-soc.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-client/: ota-client-cli.c ota-client-page-request.c ota-client-signature-verify.c ota-client.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-client-policy/: ota-client-policy.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-common/: ota-common.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-storage-common/: ota-storage-common-cli.c ota-storage-common.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-storage-simple-eeprom/: ota-storage-eeprom-page-erase.c ota-storage-eeprom-read-modify-write.c ota-storage-eeprom.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/ota-storage-simple/: ota-storage-simple-simulation.c ota-storage-simple.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/reporting/: reporting-cli.c reporting.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/scenes/: scenes-cli.c scenes.c
    ../../../protocol/zigbee_5.9/app/util/security/: security-address-cache.c
    ../../../platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
    ../../../platform/base/hal/plugin/sim-eeprom1/: sim-eeprom.c
    ../../../protocol/zigbee_5.9/app/framework/plugin/simple-main/: simple-main.c
    Uart_V2/: Uart_CmdExec.c Uart_Receiver.c Uart_Transmitter.c
    ../../../protocol/zigbee_5.9/app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
    ZigbeeUtility/: ZigbeeUtility.c
  group emdrv
    ../../../platform/emdrv/dmadrv/src/: dmadrv.c
    ../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/emdrv/sleep/src/: sleep.c
    ../../../platform/emdrv/spidrv/src/: spidrv.c
    ../../../platform/emdrv/tempdrv/src/: tempdrv.c
    ../../../platform/emdrv/uartdrv/src/: uartdrv.c
    ../../../platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/emlib/src/: em_adc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../platform/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
  group Libraries
    ../../../protocol/zigbee_5.9/build/binding-table-library-cortexm3-iar-efr32mg1p-rail/: binding-table-library.a
    ../../../protocol/zigbee_5.9/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-163k1-stub-library.a
    ../../../protocol/zigbee_5.9/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-283k1-stub-library.a
    ../../../protocol/zigbee_5.9/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-sign-stub.a
    ../../../protocol/zigbee_5.9/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../protocol/zigbee_5.9/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg1p-rail/: cbke-library-dsa-verify-stub.a
    ../../../protocol/zigbee_5.9/build/cbke-stub-library-cortexm3-iar-efr32mg1p-rail/: cbke-stub-library.a
    ../../../protocol/zigbee_5.9/build/debug-basic-library-cortexm3-iar-efr32mg1p-rail/: debug-basic-library.a
    ../../../protocol/zigbee_5.9/build/debug-extended-stub-library-cortexm3-iar-efr32mg1p-rail/: debug-extended-stub-library.a
    ../../../protocol/zigbee_5.9/build/end-device-bind-stub-library-cortexm3-iar-efr32mg1p-rail/: end-device-bind-stub-library.a
    ../../../protocol/zigbee_5.9/build/enhanced-beacon-request-stub-library-cortexm3-iar-efr32mg1p-rail/: enhanced-beacon-request-stub-library.a
    ../../../protocol/zigbee_5.9/build/gp-stub-library-cortexm3-iar-efr32mg1p-rail/: gp-stub-library.a
    ../../../protocol/zigbee_5.9/build/hal-library-cortexm3-iar-efr32mg1p-rail/: hal-library.a
    ../../../protocol/zigbee_5.9/build/install-code-library-stub-cortexm3-iar-efr32mg1p-rail/: install-code-library-stub.a
    ../../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg1_iar_release.a
    ../../../protocol/zigbee_5.9/build/multi-network-stub-library-cortexm3-iar-efr32mg1p-rail/: multi-network-stub-library.a
    ../../../protocol/zigbee_5.9/build/packet-validate-library-cortexm3-iar-efr32mg1p-rail/: packet-validate-library.a
    ../../../protocol/zigbee_5.9/build/rf4ce-stack-stub-library-cortexm3-iar-efr32mg1p-rail/: rf4ce-stack-stub-library.a
    ../../../protocol/zigbee_5.9/build/security-library-core-cortexm3-iar-efr32mg1p-rail/: security-library-core.a
    ../../../protocol/zigbee_5.9/build/security-library-link-keys-stub-cortexm3-iar-efr32mg1p-rail/: security-library-link-keys-stub.a
    ../../../protocol/zigbee_5.9/build/sim-eeprom1-library-cortexm3-iar-efr32mg1p-rail/: sim-eeprom1-library.a
    ../../../protocol/zigbee_5.9/build/zigbee-pro-stack-cortexm3-iar-efr32mg1p-rail/: zigbee-pro-stack.a
    ../../../protocol/zigbee_5.9/build/zll-stub-library-cortexm3-iar-efr32mg1p-rail/: zll-stub-library.a
